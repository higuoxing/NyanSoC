## sw/opensbi-platform/Kconfig
```kconfig
config PLATFORM_NYANSOC
	bool "NyanSoC (Tang Nano 20K)"
	select IRQCHIP_PLIC
	select TIMER_MTIMER
	default n
```
